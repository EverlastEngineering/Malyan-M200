# IAR project Backup of MM32.ewp, settings and files
configuration DEBUG (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072CB ST STM32F072CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_STM32072B_EVAL; STM32F072
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\src\fs; ..\src\js; ..\src\marlin; ..\src\rtt; ..\src\usb; ..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB_Device_Driver\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\cdc_msc_wrapper\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: firmware.bin
  ILINK.IlinkOutputFile: MM32.out
  ILINK.IlinkIcfFile: stm32f070xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../src/marlin/: Main.cpp
  group FS
    ../src/fs/: cardreader.cpp ccsbcs.c diskio.c ff.c sd.c SPI_MSD0_Driver.c
  group JS
    ../src/js/: TinyJS.cpp TinyJS_Functions.cpp TinyJS_MathFunctions.cpp
  group Motion
    ../src/marlin/: configuration_store.cpp Marlin_main.cpp MarlinSerial.cpp mesh_bed_leveling.cpp planner.cpp Platform.cpp port.c Print.cpp qr_solve.cpp servo.cpp stepper.cpp stepper_indirection.cpp temperature.cpp vector_3.cpp wifi.cpp WString.cpp
  group RTT
    ../src/rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group STM32_USB_Device_Library/Class/CDC
    ../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group STM32_USB_Device_Library/Class/MSC
    ../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c usbd_storage_template.c
    ../src/usb/: usbd_storage.c
  group STM32_USB_Device_Library/Class/WRAPPER
    ../../Libraries/STM32_USB_Device_Library/Class/cdc_msc_wrapper/src/: usbd_cdc_msc_wrapper.c
  group STM32_USB_Device_Library/Drivers
    ../../Libraries/STM32_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32_USB_Device_Library/Library
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32F0XX
    ../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f072.s
    ../src/usb/: system_stm32f0xx.c
  group STM32F0XX/STM32F072_StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group USB
    ../src/usb/: stm32_it.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_pwr.c usbd_usr.c
